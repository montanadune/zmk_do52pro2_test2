## boards/shields/do52pro_tp/Kconfig.defconfig
```kconfig
if SHIELD_DO52PRO_TP_RIGHT

config ZMK_KEYBOARD_NAME
    default "do52pro_tp"

endif
```
